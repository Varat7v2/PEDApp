*Generated netlist for the circuit diagram.
L1 2 3 92
V1 1 0 8
C1 3 0 2
R1 2 0 32
R2 3 4 30
R3 4 0 57
R4 1 2 11
.op
